# Keil uVision project 902V0-A.uvprojx, settings and files
target 902V0-A (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F071VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EepromClean-A +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F071xB
  c misc: --C99
  c include: ../DEV/Inc;../USER/Inc;../STM32F0xx_HAL_Driver/Inc;../STM32F0xx_HAL_Driver/Inc/Legacy;../LIB/CMSIS/Include;../LIB/CMSIS/Device/Include;../LIB/lib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group DEV
    ../DEV/Src/: hw_clock.c
  group LIB
    ../LIB/: startup_stm32f071xb.s system_stm32f0xx.c
    ../LIB/lib/: hfim5_conv_ad.lib HFIM5_LIB.lib
  group USER
    ../USER/Src/: logic.c main.c task.c
  group STM32F0xx_HAL_Driver
    ../STM32F0xx_HAL_Driver/Src/: hal_driver.lib
software components: CMSIS:CORE 4.3.0
